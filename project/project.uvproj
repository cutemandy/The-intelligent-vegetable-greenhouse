# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c delay.c delay.h LCD1602.h LCD1602.c AT24C02.c AT24C02.h Timer0.c Key.c Key.h I2C.c I2C.h Timer0.h BH1750.c BH1750.h DHT22.c DHT22.h
